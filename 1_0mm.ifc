Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView]
File name: 1_top_traction_2_1.ifc
Time: 2026-01-12T17:47:01+01:00
Written by: IfcOpenShell 0.8.4
Made in: Bonsai 0.8.4

# IfcBuilding, Document
LongName: Document
DigiPara - DigiPara.IfcBuildingName: Document; DigiPara.IfcExportAs: IfcBuilding; DigiPara.IfcExportType: ELEVATOR; DigiPara.IfcProjectName: Glatzel 1; DigiPara.IfcSiteName: Site; DigiPara.LDXType: LDXDocument; DigiPara.RevitTargetName: LDXDocument; DigiPara.RevitTypeName: LDXDocument
Revit Standard Parameter for IFC Export (Revit 2023 and higher) - Export Type to IFC As: IfcBuilding; Export to IFC As: IfcBuilding

# IfcBuildingStorey (6)
In: Document
Name | Elevation (mm) | GrossHeight (mm)
1 | 0 | 3350
2 | 3350 | 3340
3 | 6690 | 2600
4 | 9290 | 3800
Z -1400 | -1400 | 14790
Z 13390 | 13390 | 2400

# IfcBuildingElementProxy: Wall Opening (31)
PredefinedType: PROVISIONFORVOID; Group: EN81 - 1 - Traction elevator 2:1 - car 2 pulleys top - cwt 1 pulley top : 5000 kg - freight elevator - 3000x3500
DigiPara - DigiPara.IfcAssignsTo: Me.Shaft.; DigiPara.IfcExportAs: IfcBuildingElementProxy; DigiPara.IfcVoids: Document.Shafts.; DigiPara.LDXType: LDXHole; DigiPara.RevitTargetName: LDXHole; DigiPara.RevitTypeName: LDXHole
Revit Standard Parameter for IFC Export (Revit 2023 and higher) - Export Type to IFC As: IfcBuildingElementProxy; Export to IFC As: IfcBuildingElementProxy
Name | In | Description | DigiPara.IfcParent | DigiPara.PathName | IFC Predefined Type = Type IFC Predefined Type
Shaft0.CW.Weight.Gov.Hole0 | Z -1400 | 100 x 200 x 100 | Me.Shaft.FloorLevel. | Shaft0.CW.Weight.Gov.Hole0. | OPENING
Shaft0.CW.Weight.Gov.Hole1 | Z -1400 | 100 x 200 x 100 | Me.Shaft.FloorLevel. | Shaft0.CW.Weight.Gov.Hole1. | OPENING
Shaft0.Car.Frame.Gov.Hole0 | Z -1400 | 100 x 200 x 100 | Me.Shaft.FloorLevel. | Shaft0.Car.Frame.Gov.Hole0. | OPENING
Shaft0.Car.Frame.Gov.Hole1 | Z -1400 | 100 x 200 x 100 | Me.Shaft.FloorLevel. | Shaft0.Car.Frame.Gov.Hole1. | OPENING
Shaft0.Components.WallFixing0.Hole0 | 4 | 80 x 200 x 80 | NearestFloorLevel. | Shaft0.Components.WallFixing0.Hole0. | OPENING
Shaft0.Components.WallFixing1.Hole0 | 4 | 80 x 200 x 80 | NearestFloorLevel. | Shaft0.Components.WallFixing1.Hole0. | OPENING
Shaft0.Entries1.E0.Opening.Hole0 | 1 | 2040 x 120 x 2140 | FloorLevel. | Shaft0.Entries1.E0.Opening.Hole0. | OPENING
Shaft0.Entries1.E0.Pocket0.Hole0 | 1 | 2800 x 120 x 2380 | FloorLevel. | Shaft0.Entries1.E0.Pocket0.Hole0. | RECESS
Shaft0.Entries1.E0.ShaftDoor.DoorFixingPointList0.AnchorRail0.Hole0 | 1 | 2050 x 23 x 41 | FloorLevel. | Shaft0.Entries1.E0.ShaftDoor.DoorFixingPointList0.AnchorRail0.Hole0. | RECESS
Shaft0.Entries1.E0.ShaftDoor.DoorFixingPointList1.AnchorRail0.Hole0 | 1 | 2050 x 23 x 41 | FloorLevel. | Shaft0.Entries1.E0.ShaftDoor.DoorFixingPointList1.AnchorRail0.Hole0. | RECESS
Shaft0.Entries1.E0.ShaftDoor.DoorFixingPointList2.AnchorRail0.Hole0 | 1 | 1000 x 23 x 41 | FloorLevel. | Shaft0.Entries1.E0.ShaftDoor.DoorFixingPointList2.AnchorRail0.Hole0. | RECESS
Shaft0.Entries1.E0.ShaftDoor.DoorFixingPointList3.AnchorRail0.Hole0 | 1 | 1000 x 23 x 41 | FloorLevel. | Shaft0.Entries1.E0.ShaftDoor.DoorFixingPointList3.AnchorRail0.Hole0. | RECESS
Shaft0.Entries2.E0.Opening.Hole0 | 2 | 2040 x 120 x 2140 | FloorLevel. | Shaft0.Entries2.E0.Opening.Hole0. | OPENING
Shaft0.Entries2.E0.Pocket0.Hole0 | 2 | 2800 x 120 x 2380 | FloorLevel. | Shaft0.Entries2.E0.Pocket0.Hole0. | RECESS
Shaft0.Entries2.E0.ShaftDoor.DoorFixingPointList0.AnchorRail0.Hole0 | 2 | 2189 x 23 x 41 | FloorLevel. | Shaft0.Entries2.E0.ShaftDoor.DoorFixingPointList0.AnchorRail0.Hole0. | RECESS
Shaft0.Entries2.E0.ShaftDoor.DoorFixingPointList1.AnchorRail0.Hole0 | 2 | 2045 x 23 x 41 | FloorLevel. | Shaft0.Entries2.E0.ShaftDoor.DoorFixingPointList1.AnchorRail0.Hole0. | RECESS
Shaft0.Entries2.E1.Opening.Hole0 | 3 | 2040 x 120 x 2140 | FloorLevel. | Shaft0.Entries2.E1.Opening.Hole0. | OPENING
Shaft0.Entries2.E1.Pocket0.Hole0 | 3 | 2800 x 120 x 2380 | FloorLevel. | Shaft0.Entries2.E1.Pocket0.Hole0. | RECESS
Shaft0.Entries2.E1.ShaftDoor.DoorFixingPointList0.AnchorRail0.Hole0 | 3 | 2189 x 23 x 41 | FloorLevel. | Shaft0.Entries2.E1.ShaftDoor.DoorFixingPointList0.AnchorRail0.Hole0. | RECESS
Shaft0.Entries2.E1.ShaftDoor.DoorFixingPointList1.AnchorRail0.Hole0 | 3 | 2045 x 23 x 41 | FloorLevel. | Shaft0.Entries2.E1.ShaftDoor.DoorFixingPointList1.AnchorRail0.Hole0. | RECESS
Shaft0.Entries2.E2.Opening.Hole0 | 4 | 2040 x 120 x 2140 | FloorLevel. | Shaft0.Entries2.E2.Opening.Hole0. | OPENING
Shaft0.Entries2.E2.Pocket0.Hole0 | 4 | 2800 x 120 x 2380 | FloorLevel. | Shaft0.Entries2.E2.Pocket0.Hole0. | RECESS
Shaft0.Entries2.E2.ShaftDoor.DoorFixingPointList0.AnchorRail0.Hole0 | 4 | 2189 x 23 x 41 | FloorLevel. | Shaft0.Entries2.E2.ShaftDoor.DoorFixingPointList0.AnchorRail0.Hole0. | RECESS
Shaft0.Entries2.E2.ShaftDoor.DoorFixingPointList1.AnchorRail0.Hole0 | 4 | 2045 x 23 x 41 | FloorLevel. | Shaft0.Entries2.E2.ShaftDoor.DoorFixingPointList1.AnchorRail0.Hole0. | RECESS
Shaft0.Gear.Hole0 | Z 13390 | 250 x 200 x 250 | Me.Shaft.MachineryRoom.FloorLevel. | Shaft0.Gear.Hole0. | OPENING
Shaft0.Gear.Hole1 | Z 13390 | 250 x 200 x 250 | Me.Shaft.MachineryRoom.FloorLevel. | Shaft0.Gear.Hole1. | OPENING
Shaft0.MachineryRoom.Door.Hole0 | Z 13390 | 900 x 200 x 2100 | Document.Shaft0.MachineryRoom.FloorLevel. | Shaft0.MachineryRoom.Door.Hole0. | OPENING
Shaft0.MachineryRoom.DuctHole.Hole0 | Z 13390 | 120 x 200 x 120 | Document.Shaft0.MachineryRoom.FloorLevel. | Shaft0.MachineryRoom.DuctHole.Hole0. | OPENING
Shaft0.MachineryRoom.Fan.Hole0 | Z 13390 | 250 x 200 x 250 | Document.Shaft0.MachineryRoom.FloorLevel. | Shaft0.MachineryRoom.Fan.Hole0. | OPENING
Shaft0.MachineryRoom.VentilationWindow.Hole0 | Z 13390 | 250 x 200 x 250 | Document.Shaft0.MachineryRoom.FloorLevel. | Shaft0.MachineryRoom.VentilationWindow.Hole0. | OPENING
Shaft0.Ventilation.Hole0 | 4 | 200 x 200 x 200 | NearestFloorLevel. | Shaft0.Ventilation.Hole0. | OPENING

# IfcBuildingSystem, EN81 - 1 - Traction elevator 2:1 - car 2 pulleys top - cwt 1 pulley top : 5000 kg - freight elevator - 3000x3500
PredefinedType: TRANSPORT; LongName: EN81 - 1 - Traction elevator 2:1 - car 2 pulleys top - cwt 1 pulley top : 5000 kg - freight elevator - 3000x3500
DigiPara - DigiPara.IfcExportAs: IfcBuildingSystem; DigiPara.IfcExportType: ELEVATOR; DigiPara.IfcParent: Document.; DigiPara.LDXType: LDXShaft; DigiPara.PathName: Shaft0.; DigiPara.RevitTargetName: LDXShaft; DigiPara.RevitTypeName: LDXShaft
Revit Standard Parameter - Assembly Code: D1010; Manufacturer: DigiPara AG; Model: DigiPara AG; OmniClass Number: 23.23.11.11; Type Comments: DigiPara AG; UniClass Number: EF_80_50
Revit Standard Parameter for IFC Export (Revit 2023 and higher) - Export Type to IFC As: IfcBuildingSystem; Export to IFC As: IfcBuildingSystem

# IfcDoor: K6Z (2)
In: Z -1400
Description: K6Z/** unknown **/1800; OverallHeight: 2000 mm; OverallWidth: 1800 mm; PredefinedType: DOOR; OperationType: USERDEFINED; Group: EN81 - 1 - Traction elevator 2:1 - car 2 pulleys top - cwt 1 pulley top : 5000 kg - freight elevator - 3000x3500
DigiPara - DigiPara.IfcAssignsTo: Me.Shaft.; DigiPara.IfcExportAs: IfcDoor; DigiPara.IfcExportType: ELEVATOR; DigiPara.IfcParent: Me.Shaft.FloorLevel.; DigiPara.LDXType: LDXCarDoor; DigiPara.RevitTargetName: CarDoor; DigiPara.RevitTypeName: CarDoor
Revit Standard Parameter - Assembly Code: D1010; Description: 0; Manufacturer: ** unknown **; Model: K6Z; OmniClass Number: 23.23.11.11.21.11; UniClass Number: Pr_30_59_46_46
Revit Standard Parameter for IFC Export (Revit 2023 and higher) - Export Type to IFC As: IfcDoor; Export to IFC As: IfcDoor
Name | DigiPara.PathName
Shaft0.Car.Door1 | Shaft0.Car.Door1.
Shaft0.Car.Door2 | Shaft0.Car.Door2.

# IfcDoor: Machine Room Door, Shaft0.MachineryRoom.Door
In: Z 13390
Description: Machine room door/Common components/900 x 2000; OverallHeight: 2000 mm; OverallWidth: 900 mm; PredefinedType: DOOR; Group: EN81 - 1 - Traction elevator 2:1 - car 2 pulleys top - cwt 1 pulley top : 5000 kg - freight elevator - 3000x3500

# IfcDoor: S6Z (4)
Description: S6Z/** unknown **/1800; OverallHeight: 2000 mm; OverallWidth: 1800 mm; PredefinedType: DOOR; OperationType: USERDEFINED; Group: EN81 - 1 - Traction elevator 2:1 - car 2 pulleys top - cwt 1 pulley top : 5000 kg - freight elevator - 3000x3500
DigiPara - DigiPara.IfcAssignsTo: Me.Shaft.; DigiPara.IfcExportAs: IfcDoor; DigiPara.IfcExportType: ELEVATOR; DigiPara.IfcFills: Parent.Opening.Hole0.; DigiPara.IfcParent: FloorLevel.; DigiPara.LDXType: LDXLandingDoor; DigiPara.RevitTargetName: LandingDoor; DigiPara.RevitTypeName: LandingDoor
Revit Standard Parameter - Assembly Code: D1010; Description: 0; Manufacturer: ** unknown **; Model: S6Z; OmniClass Number: 23.23.11.11.21.11; UniClass Number: Pr_30_59_46_46
Revit Standard Parameter for IFC Export (Revit 2023 and higher) - Export Type to IFC As: IfcDoor; Export to IFC As: IfcDoor
Name | In | DigiPara.PathName
Shaft0.Entries1.E0.ShaftDoor | 1 | Shaft0.Entries1.E0.ShaftDoor.
Shaft0.Entries2.E0.ShaftDoor | 2 | Shaft0.Entries2.E0.ShaftDoor.
Shaft0.Entries2.E1.ShaftDoor | 3 | Shaft0.Entries2.E1.ShaftDoor.
Shaft0.Entries2.E2.ShaftDoor | 4 | Shaft0.Entries2.E2.ShaftDoor.

# IfcElectricDistributionBoard: Schalttafel, Shaft0.MachineryRoom.SGC0
In: Z 13390
Description: Schalttafel/Common components/Standard; PredefinedType: SWITCHBOARD; Group: EN81 - 1 - Traction elevator 2:1 - car 2 pulleys top - cwt 1 pulley top : 5000 kg - freight elevator - 3000x3500

# IfcElectricMotor: Type "A" - MF 94 - frequency, Shaft0.Gear
In: Z 13390
Description: Type "A" - MF 94 - frequency/** unknown **/type R; Group: EN81 - 1 - Traction elevator 2:1 - car 2 pulleys top - cwt 1 pulley top : 5000 kg - freight elevator - 3000x3500

# IfcFan: Fan, Shaft0.MachineryRoom.Fan
In: Z 13390
Description: Fan/Common components/Standard; Group: EN81 - 1 - Traction elevator 2:1 - car 2 pulleys top - cwt 1 pulley top : 5000 kg - freight elevator - 3000x3500

# IfcLamp: Shaft Lighting (8)
Description: Lamp/Common components/Round; Group: EN81 - 1 - Traction elevator 2:1 - car 2 pulleys top - cwt 1 pulley top : 5000 kg - freight elevator - 3000x3500
Name | In
Shaft0.LampList.Lamp0 | 1
Shaft0.LampList.Lamp1 | 1
Shaft0.LampList.Lamp2 | 2
Shaft0.LampList.Lamp3 | 2
Shaft0.LampList.Lamp4 | 3
Shaft0.LampList.Lamp5 | 4
Shaft0.LampList.Lamp6 | 4
Shaft0.MachineryRoom.Lamp0 | Z 13390

# IfcMechanicalFastener: HTA 40/22 (34)
NominalDiameter: 40 mm; PredefinedType: ANCHORBOLT; Group: EN81 - 1 - Traction elevator 2:1 - car 2 pulleys top - cwt 1 pulley top : 5000 kg - freight elevator - 3000x3500
Name | In | Description | NominalLength (mm)
Shaft0.CW.BracketList.Bracket0.AnchorRail0 | 1 | HTA 40/22/** unknown **/262 x 40 | 600
Shaft0.CW.BracketList.Bracket0.AnchorRail1 | 1 | HTA 40/22/** unknown **/262 x 40 | 600
Shaft0.CW.BracketList.Bracket1.AnchorRail0 | 1 | HTA 40/22/** unknown **/262 x 40 | 600
Shaft0.CW.BracketList.Bracket1.AnchorRail1 | 1 | HTA 40/22/** unknown **/262 x 40 | 600
Shaft0.CW.BracketList.Bracket2.AnchorRail0 | 2 | HTA 40/22/** unknown **/262 x 40 | 600
Shaft0.CW.BracketList.Bracket2.AnchorRail1 | 2 | HTA 40/22/** unknown **/262 x 40 | 600
Shaft0.CW.BracketList.Bracket3.AnchorRail0 | 2 | HTA 40/22/** unknown **/262 x 40 | 600
Shaft0.CW.BracketList.Bracket3.AnchorRail1 | 2 | HTA 40/22/** unknown **/262 x 40 | 600
Shaft0.CW.BracketList.Bracket4.AnchorRail0 | 3 | HTA 40/22/** unknown **/262 x 40 | 600
Shaft0.CW.BracketList.Bracket4.AnchorRail1 | 3 | HTA 40/22/** unknown **/262 x 40 | 600
Shaft0.CW.BracketList.Bracket5.AnchorRail0 | 4 | HTA 40/22/** unknown **/262 x 40 | 600
Shaft0.CW.BracketList.Bracket5.AnchorRail1 | 4 | HTA 40/22/** unknown **/262 x 40 | 600
Shaft0.CW.BracketList.Bracket6.AnchorRail0 | 4 | HTA 40/22/** unknown **/262 x 40 | 600
Shaft0.CW.BracketList.Bracket6.AnchorRail1 | 4 | HTA 40/22/** unknown **/262 x 40 | 600
Shaft0.CW.BracketList.Bracket7.AnchorRail0 | 4 | HTA 40/22/** unknown **/262 x 40 | 600
Shaft0.CW.BracketList.Bracket7.AnchorRail1 | 4 | HTA 40/22/** unknown **/262 x 40 | 600
Shaft0.Entries1.E0.ShaftDoor.DoorFixingPointList0.AnchorRail0 | 1 | HTA 40/22/** unknown **/262 x 40 | 2050
Shaft0.Entries1.E0.ShaftDoor.DoorFixingPointList1.AnchorRail0 | 1 | HTA 40/22/** unknown **/262 x 40 | 2050
Shaft0.Entries1.E0.ShaftDoor.DoorFixingPointList2.AnchorRail0 | 1 | HTA 40/22/** unknown **/262 x 40 | 1000
Shaft0.Entries1.E0.ShaftDoor.DoorFixingPointList3.AnchorRail0 | 1 | HTA 40/22/** unknown **/262 x 40 | 1000
Shaft0.Entries2.E0.ShaftDoor.DoorFixingPointList0.AnchorRail0 | 2 | HTA 40/22/** unknown **/262 x 40 | 2189
Shaft0.Entries2.E0.ShaftDoor.DoorFixingPointList1.AnchorRail0 | 2 | HTA 40/22/** unknown **/262 x 40 | 2045
Shaft0.Entries2.E1.ShaftDoor.DoorFixingPointList0.AnchorRail0 | 3 | HTA 40/22/** unknown **/262 x 40 | 2189
Shaft0.Entries2.E1.ShaftDoor.DoorFixingPointList1.AnchorRail0 | 3 | HTA 40/22/** unknown **/262 x 40 | 2045
Shaft0.Entries2.E2.ShaftDoor.DoorFixingPointList0.AnchorRail0 | 4 | HTA 40/22/** unknown **/262 x 40 | 2189
Shaft0.Entries2.E2.ShaftDoor.DoorFixingPointList1.AnchorRail0 | 4 | HTA 40/22/** unknown **/262 x 40 | 2045
Shaft0.RailBracket4.BracketList.Bracket0.AnchorRail0 | 1 | HTA 40/22/Common components/262 x 40 | 200
Shaft0.RailBracket4.BracketList.Bracket1.AnchorRail0 | 1 | HTA 40/22/Common components/262 x 40 | 200
Shaft0.RailBracket4.BracketList.Bracket2.AnchorRail0 | 2 | HTA 40/22/Common components/262 x 40 | 200
Shaft0.RailBracket4.BracketList.Bracket3.AnchorRail0 | 2 | HTA 40/22/Common components/262 x 40 | 200
Shaft0.RailBracket4.BracketList.Bracket4.AnchorRail0 | 3 | HTA 40/22/Common components/262 x 40 | 200
Shaft0.RailBracket4.BracketList.Bracket5.AnchorRail0 | 4 | HTA 40/22/Common components/262 x 40 | 200
Shaft0.RailBracket4.BracketList.Bracket6.AnchorRail0 | 4 | HTA 40/22/Common components/262 x 40 | 200
Shaft0.RailBracket4.BracketList.Bracket7.AnchorRail0 | 4 | HTA 40/22/Common components/262 x 40 | 200

# IfcSpatialZone: Machinery Room, Shaft0.MachineryRoom
In: Z 13390
Description: Machinery Room; PredefinedType: OCCUPANCY; Group: EN81 - 1 - Traction elevator 2:1 - car 2 pulleys top - cwt 1 pulley top : 5000 kg - freight elevator - 3000x3500
DigiPara - DigiPara.IfcAssignsTo: Me.Shaft.; DigiPara.IfcExportAs: IfcSpatialZone; DigiPara.IfcParent: FloorLevel.; DigiPara.IfcServicedBy: Me.Shaft.; DigiPara.IfcVoids: Document.Shafts.; DigiPara.LDXType: LDXHole; DigiPara.PathName: Shaft0.MachineryRoom.Hole0.; DigiPara.RevitTargetName: LDXHole; DigiPara.RevitTypeName: LDXHole
Revit Standard Parameter for IFC Export (Revit 2023 and higher) - Export Type to IFC As: IfcSpatialZone; Export to IFC As: IfcSpatialZone; IFC Predefined Type: OPENING; Type IFC Predefined Type: OPENING

# IfcSpatialZone: Refuge Space (3)
PredefinedType: SECURITY; Group: EN81 - 1 - Traction elevator 2:1 - car 2 pulleys top - cwt 1 pulley top : 5000 kg - freight elevator - 3000x3500
DigiPara - DigiPara.IfcAssignsTo: Me.Shaft.; DigiPara.IfcExportAs: IfcSpatialZone; DigiPara.IfcExportType: ELEVATOR; DigiPara.LDXType: LDXRefugeSpace; DigiPara.RevitTargetName: LDXRefugeSpace; DigiPara.RevitTypeName: LDXRefugeSpace
Revit Standard Parameter - Assembly Code: D1010
Revit Standard Parameter for IFC Export (Revit 2023 and higher) - Export Type to IFC As: IfcSpatialZone; Export to IFC As: IfcSpatialZone
Name | In | DigiPara.IfcParent | DigiPara.PathName
Shaft0.Car.RefugeSpace | Z -1400 | Me.Shaft.FloorLevel. | Shaft0.Car.RefugeSpace.
Shaft0.MachineryRoom.SGC0.RefugeSpace | Z 13390 | Document.Shaft0.MachineryRoom.FloorLevel. | Shaft0.MachineryRoom.SGC0.RefugeSpace.
Shaft0.RefugeSpace | Z -1400 | Shaft.FloorLevel. | Shaft0.RefugeSpace.

# IfcSpatialZone: Shaft, Shaft0
In: Z -1400
Description: Shaft; PredefinedType: OCCUPANCY; Group: EN81 - 1 - Traction elevator 2:1 - car 2 pulleys top - cwt 1 pulley top : 5000 kg - freight elevator - 3000x3500
DigiPara - DigiPara.IfcAssignsTo: Me.Shaft.; DigiPara.IfcExportAs: IfcSpatialZone; DigiPara.IfcParent: FloorLevel.; DigiPara.IfcServicedBy: Me.Shaft.; DigiPara.IfcVoids: Document.Shafts.; DigiPara.LDXType: LDXShaftDimensions; DigiPara.PathName: Shaft0.Hole0.; DigiPara.RevitTargetName: LDXHole; DigiPara.RevitTypeName: LDXHole
Revit Standard Parameter for IFC Export (Revit 2023 and higher) - Export Type to IFC As: IfcSpatialZone; Export to IFC As: IfcSpatialZone; IFC Predefined Type: OPENING; Type IFC Predefined Type: OPENING

# IfcSwitchingDevice: Cabin display (2)
In: Z -1400
Description: Cabin display/Common components/Installation in cabin; Group: EN81 - 1 - Traction elevator 2:1 - car 2 pulleys top - cwt 1 pulley top : 5000 kg - freight elevator - 3000x3500
DigiPara - DigiPara.IfcAssignsTo: Me.Shaft.; DigiPara.IfcExportAs: IfcSwitchingDevice; DigiPara.IfcExportType: ELEVATOR; DigiPara.IfcFills: Me.Hole0.; DigiPara.IfcParent: Me.Shaft.FloorLevel.; DigiPara.LDXType: LDXHallButton; DigiPara.RevitTargetName: HallButton; DigiPara.RevitTypeName: HallButton
Revit Standard Parameter - Assembly Code: D1010; Manufacturer: Common components; Model: Cabin display; OmniClass Number: 23.23.11.11.21.13; Type Comments: Installation in cabin; UniClass Number: Pr_30_59_61_33
Revit Standard Parameter for IFC Export (Revit 2023 and higher) - Export Type to IFC As: IfcSwitchingDevice; Export to IFC As: IfcSwitchingDevice
Name | DigiPara.PathName
Shaft0.Car.Panel0 | Shaft0.Car.Panel0.
Shaft0.Car.Panel1 | Shaft0.Car.Panel1.

# IfcTransportElement: Car, Shaft0.Car
In: Z -1400
PredefinedType: ELEVATOR; Group: EN81 - 1 - Traction elevator 2:1 - car 2 pulleys top - cwt 1 pulley top : 5000 kg - freight elevator - 3000x3500
DigiPara - DigiPara.IfcAssignsTo: Me.Shaft.; DigiPara.IfcExportAs: IfcTransportElement; DigiPara.IfcExportType: ELEVATOR; DigiPara.IfcParent: Me.Shaft.FloorLevel.; DigiPara.LDXType: LDXCar; DigiPara.PathName: Shaft0.Car.; DigiPara.RevitTargetName: LDXCar; DigiPara.RevitTypeName: LDXCar
Revit Standard Parameter - Assembly Code: D1010; Manufacturer: Common components; OmniClass Number: 23.23.11.11.19; UniClass Number: Pr_80_77_46_46
Revit Standard Parameter for IFC Export (Revit 2023 and higher) - Export Type to IFC As: IfcTransportElement; Export to IFC As: IfcTransportElement

# IfcTransportElement: Counterweight, Shaft0.CW.Weight
In: Z -1400
Description: Counterweight/Common components/Standard - 4:1 - 2 pulleys top; PredefinedType: ELEVATOR; Group: EN81 - 1 - Traction elevator 2:1 - car 2 pulleys top - cwt 1 pulley top : 5000 kg - freight elevator - 3000x3500
DigiPara - DigiPara.IfcAssignsTo: Me.Shaft.; DigiPara.IfcExportAs: IfcTransportElement; DigiPara.IfcExportType: ELEVATOR; DigiPara.IfcParent: Me.Shaft.FloorLevel.; DigiPara.LDXType: LDXCWFrame; DigiPara.PathName: Shaft0.CW.Weight.; DigiPara.RevitTargetName: CWFrame; DigiPara.RevitTypeName: CWFrame
Revit Standard Parameter - Assembly Code: D1010; Description: 0; Manufacturer: Common components; Model: Counterweight; OmniClass Number: 23.23.11.11; Type Comments: Standard - 4:1 - 2 pulleys top; UniClass Number: EF_80_50
Revit Standard Parameter for IFC Export (Revit 2023 and higher) - Export Type to IFC As: IfcTransportElement; Export to IFC As: IfcTransportElement

# IfcTransportElement: Guide Rail (12)
PredefinedType: ELEVATOR; Group: EN81 - 1 - Traction elevator 2:1 - car 2 pulleys top - cwt 1 pulley top : 5000 kg - freight elevator - 3000x3500
Name | In | Description
Shaft0.CW.Weight.GuideList0.Guide0 | 1 | T 70-1/A/Common components/diagonal base, cold drawn
Shaft0.CW.Weight.GuideList0.Guide1 | 2 | T 70-1/A/Common components/diagonal base, cold drawn
Shaft0.CW.Weight.GuideList0.Guide2 | 4 | T 70-1/A/Common components/diagonal base, cold drawn
Shaft0.CW.Weight.GuideList1.Guide0 | 1 | T 70-1/A/Common components/diagonal base, cold drawn
Shaft0.CW.Weight.GuideList1.Guide1 | 2 | T 70-1/A/Common components/diagonal base, cold drawn
Shaft0.CW.Weight.GuideList1.Guide2 | 4 | T 70-1/A/Common components/diagonal base, cold drawn
Shaft0.Car.Frame.GuideList0.Guide0 | 1 | T 125/B/Common components/diagonal base, machined
Shaft0.Car.Frame.GuideList0.Guide1 | 2 | T 125/B/Common components/diagonal base, machined
Shaft0.Car.Frame.GuideList0.Guide2 | 4 | T 125/B/Common components/diagonal base, machined
Shaft0.Car.Frame.GuideList1.Guide0 | 1 | T 125/B/Common components/diagonal base, machined
Shaft0.Car.Frame.GuideList1.Guide1 | 2 | T 125/B/Common components/diagonal base, machined
Shaft0.Car.Frame.GuideList1.Guide2 | 4 | T 125/B/Common components/diagonal base, machined

# IfcTransportElement: Ladder 300x80, Shaft0.Ladder
In: Z -1400
Description: Ladder 300x80/Common components/Ladder 300x80; PredefinedType: ELEVATOR; Group: EN81 - 1 - Traction elevator 2:1 - car 2 pulleys top - cwt 1 pulley top : 5000 kg - freight elevator - 3000x3500

# IfcTransportElement: Machine bed, Shaft0.Gear.GearFrame
In: Z 13390
Description: Machine bed/Common components/without deflection sheave - simple frame - right side; PredefinedType: ELEVATOR; Group: EN81 - 1 - Traction elevator 2:1 - car 2 pulleys top - cwt 1 pulley top : 5000 kg - freight elevator - 3000x3500

# IfcTransportElement: Pulley (4)
In: Z -1400
PredefinedType: ELEVATOR; Group: EN81 - 1 - Traction elevator 2:1 - car 2 pulleys top - cwt 1 pulley top : 5000 kg - freight elevator - 3000x3500
Name | Description
Shaft0.CW.Weight.Support0.SH0 | Common pulley/Common components/400 mm
Shaft0.CW.Weight.Support1.SH0 | Common pulley/Common components/400 mm
Shaft0.Car.Frame.Support0.SH0 | Common pulley/Common components/360 mm
Shaft0.Car.Frame.Support0.SH1 | Common pulley/Common components/360 mm

# IfcTransportElement: Rail bracket for concrete fixing (8)
Description: Rail bracket for concrete fixing/Common components/CWT guides; PredefinedType: ELEVATOR; Group: EN81 - 1 - Traction elevator 2:1 - car 2 pulleys top - cwt 1 pulley top : 5000 kg - freight elevator - 3000x3500
Name | In
Shaft0.RailBracket4.BracketList.Bracket0 | 1
Shaft0.RailBracket4.BracketList.Bracket1 | 1
Shaft0.RailBracket4.BracketList.Bracket2 | 2
Shaft0.RailBracket4.BracketList.Bracket3 | 2
Shaft0.RailBracket4.BracketList.Bracket4 | 3
Shaft0.RailBracket4.BracketList.Bracket5 | 4
Shaft0.RailBracket4.BracketList.Bracket6 | 4
Shaft0.RailBracket4.BracketList.Bracket7 | 4

# IfcTransportElement: Rail bracket for self-construction (8)
Description: Rail bracket for self-construction/Common components/CWT and car guides - side drop; PredefinedType: ELEVATOR; Group: EN81 - 1 - Traction elevator 2:1 - car 2 pulleys top - cwt 1 pulley top : 5000 kg - freight elevator - 3000x3500
Name | In
Shaft0.CW.BracketList.Bracket0 | 1
Shaft0.CW.BracketList.Bracket1 | 1
Shaft0.CW.BracketList.Bracket2 | 2
Shaft0.CW.BracketList.Bracket3 | 2
Shaft0.CW.BracketList.Bracket4 | 3
Shaft0.CW.BracketList.Bracket5 | 4
Shaft0.CW.BracketList.Bracket6 | 4
Shaft0.CW.BracketList.Bracket7 | 4

# IfcTransportElement: Spring buffer (4)
In: Z -1400
Description: Spring buffer/Common components/80 mm; PredefinedType: ELEVATOR; Group: EN81 - 1 - Traction elevator 2:1 - car 2 pulleys top - cwt 1 pulley top : 5000 kg - freight elevator - 3000x3500
Name
Shaft0.CW.Weight.Buffer0
Shaft0.CW.Weight.Buffer1
Shaft0.Car.Frame.Buffer0
Shaft0.Car.Frame.Buffer1

# IfcTransportElement: Traction Sheave, Shaft0.Gear.SH0
In: Z 13390
Description: Traction sheave MF 94/** unknown **/650 mm; PredefinedType: ELEVATOR; Group: EN81 - 1 - Traction elevator 2:1 - car 2 pulleys top - cwt 1 pulley top : 5000 kg - freight elevator - 3000x3500

# IfcTransportElement: Ventilation window, Shaft0.MachineryRoom.VentilationWindow
In: Z 13390
Description: Ventilation window/Common components/Standard; PredefinedType: ELEVATOR; Group: EN81 - 1 - Traction elevator 2:1 - car 2 pulleys top - cwt 1 pulley top : 5000 kg - freight elevator - 3000x3500
